# IAR project Examples.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1343 NXP LPC1343
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include; ..\Lib_EaBaseBoard\inc; ..\Lib_MCU\inc; ..\RTOS\RTX\INC
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Examples.srec
  ILINK.IlinkOutputFile: laboratories.out
  ILINK.IlinkIcfFile: src\lpc1343.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: Examples.out
  group Libraries
    ../Lib_EaBaseBoard/Debug/Exe/: Lib_EaBaseBoard.a
    ../Lib_MCU/Debug/Exe/: Lib_MCU.a
    ../RTOS/RTX/SRC/IAR/CM3_LE/: RTX_Lib_CM.a
  group Sources
    src/: libdemo.h RTX_Conf_CM.c
  group Sources/example_board_demo
    src/: example_board_demo.c
  group Sources/example_C_ASM
    src/: example_asm_function.s example_mainC.c
  group Sources/example_Gantt_diagram
    src/: example_gantt.c
  group Sources/example_RTOS_1_thread
    src/: example_1_thread.c
  group Sources/example_RTOS_2_timer
    src/: example_2_timer.c
  group Sources/example_RTOS_3_signal
    src/: example_3_signal.c
  group Sources/example_RTOS_4_mutex
    src/: example_4_mutex.c
  group Sources/example_RTOS_5_semaphore
    src/: example_5_semaphore.c
  group Sources/example_RTOS_6_isr
    src/: example_6_isr.c
  group Sources/example_RTOS_7_mail_queue
    src/: example_7_mail_queue.c
  group Sources/example_RTOS_8_memory_pool
    src/: example_8_memory_pool.c
  group Sources/lab_0
    src/: lab_0_asm.s lab_0_main.c
  group Sources/lab_1
    src/: lab_1_main.c
  group Startup
    ../Device/NXP/LPC13xx/Source/IAR/: startup_LPC13xx.s
    ../Device/NXP/LPC13xx/Source/: system_LPC13xx.c
