# IAR project Backup (4) of Lib_EaBaseBoard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lib_EaBaseBoard.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: acc.c eeprom.c flash.c font5x7.c joystick.c led7seg.c light.c oled.c pca9532.c rgb.c rotary.c temp.c uart2.c
