# IAR project Backup (3) of Lib_EaBaseBoard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG
  ICCARM.CCIncludePath2: inc; ..\Lib_MCU\inc; ..\Device\NXP\LPC13xx\Include\; ..\Drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: Lib_EaBaseBoard.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: acc.c eeprom.c flash.c font5x7.c joystick.c led7seg.c light.c oled.c pca9532.c rgb.c rotary.c temp.c uart2.c
