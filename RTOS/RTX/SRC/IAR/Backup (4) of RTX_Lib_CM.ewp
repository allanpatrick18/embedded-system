# IAR project Backup (4) of RTX_Lib_CM.ewp, settings and files
configuration CM0_LE (ARM)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM0.a"
configuration CM0_BE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM0_B.a"
configuration CM3_LE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM3.a"
configuration CM3_BE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM3_B.a"
configuration CM4F_LE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM4.a"
configuration CM4F_BE (ARM)
  as the first configuration, except:
  postbuild: cmd.exe /C copy "$TARGET_PATH$" "..\..\LIB\IAR\RTX_CM4_B.a"
  group HAL
    ../: HAL_CM.c
    ./: HAL_CM0.s HAL_CM3.s HAL_CM4.s SVC_Table.s
  group Kernel
    ../: rt_CMSIS.c rt_Event.c rt_List.c rt_Mailbox.c rt_MemBox.c rt_Memory.c rt_Mutex.c rt_Robin.c rt_Semaphore.c rt_System.c rt_Task.c rt_Time.c rt_Timer.c
