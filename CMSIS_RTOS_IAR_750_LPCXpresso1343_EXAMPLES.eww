<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Examples\Examples.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Lib_EaBaseBoard\Lib_EaBaseBoard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Lib_MCU\Lib_MCU.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RTOS\RTX\SRC\IAR\RTX_Lib_CM.ewp</path>
  </project>
  <batchBuild/>
</workspace>


